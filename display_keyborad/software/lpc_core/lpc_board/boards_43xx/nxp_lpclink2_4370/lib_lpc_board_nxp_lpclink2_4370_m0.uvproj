# Keil uVision project lib_lpc_board_nxp_lpclink2_4370_m0.uvproj, settings and files
target nxp_lpclink2_4370_m0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lib_lpc_board_4370_m0 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\lpc_chip\chip_common;..\..\board_common;.
  group src
    ./: board.c board_sysinit.c
