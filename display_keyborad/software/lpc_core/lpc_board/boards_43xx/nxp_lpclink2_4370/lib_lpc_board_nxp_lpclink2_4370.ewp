# IAR project lib_lpc_board_nxp_lpclink2_4370.ewp, settings and files
configuration nxp_lpclink2_4370 (ARM)
  General.OGChipSelectEditMenu: LPC4370_M4 NXP LPC4370_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../lpc_chip/chip_18xx_43xx; ../../../lpc_chip/chip_18xx_43xx/config_43xx; ../../../lpc_chip/chip_common; ../../../../CMSIS/CMSIS/Include; ../../board_common; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: lib_lpc_board_nxp_lpclink2_4370.out
  group src
    ./: board.c board_sysinit.c
