# Keil uVision project lib_lpc_chip_43xx_m0.uvproj, settings and files
target lib_lpc_chip_43xx_m0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4350 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lib_lpc_chip_43xx_m0 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: .\;.\config_43xx_m0app;..\chip_common
  group src
    ../chip_common/: ring_buffer.c
    ./: stopwatch_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pmc_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c sct_pwm_18xx_43xx.c scu_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c ssp_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c hsadc_18xx_43xx.c
