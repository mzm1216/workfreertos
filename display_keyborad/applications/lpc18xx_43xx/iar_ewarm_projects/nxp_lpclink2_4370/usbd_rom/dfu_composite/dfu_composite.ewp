# IAR project dfu_composite.ewp, settings and files
configuration spifi_nxp_lpclink2_4370 (ARM)
  General.OGChipSelectEditMenu: LPC4370_M4 NXP LPC4370_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpclink2_4370; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom; ..\..\..\..\examples\usbd_rom\usbd_rom_dfu_composite
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: periph_blinky.srec
  ILINK.IlinkOutputFile: dfu_composite.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_ldscript_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/usbd_rom/usbd_rom_dfu_composite/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpclink2_4370/iar_output/nxp_lpclink2_4370/Exe/: lib_lpc_board_nxp_lpclink2_4370.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../examples/usbd_rom/usbd_rom_dfu_composite/: cdc_vcom.c composite_usbdesc.c hid_mouse.c main.c msc_ram.c usbd_dfu.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
