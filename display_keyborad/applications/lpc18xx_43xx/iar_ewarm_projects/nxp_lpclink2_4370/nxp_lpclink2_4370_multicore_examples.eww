<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpclink2_4370\lib_lpc_board_nxp_lpclink2_4370_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpclink2_4370\lib_lpc_board_nxp_lpclink2_4370.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\multicore\sa_blinky_m0app\sa_blinky_m0app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\multicore\sa_blinky_m0sub\sa_blinky_m0sub.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\multicore\sa_blinky_m4\sa_blinky_m4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


