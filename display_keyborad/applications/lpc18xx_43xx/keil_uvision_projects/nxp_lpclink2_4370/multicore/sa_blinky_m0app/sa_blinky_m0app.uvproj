# Keil uVision project sa_blinky_m0app.uvproj, settings and files
target iflash_nxp_lpclink2_4370 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: sa_blinky_m0app
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpclink2_4370;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\multicore\common;..\..\..\..\examples\multicore\sa_blinky_m0
  memory RVCT4: ROM 0x14010000 size 0x10000
  memory RVCT9: RAM 0x10080000 size 0x8000
  group src
    ../../../../examples/multicore/common/: ipc_example.c ipc_msg.c readme.txt
    ../../../../startup_code/: sysinit.c keil_startup_lpc43xx_m0app.s
    ../../../../examples/multicore/sa_blinky_m0/: blinky_m0.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpclink2_4370/keil_output/core_m0/: lib_lpc_board_nxp_lpclink2_4370_m0.lib
