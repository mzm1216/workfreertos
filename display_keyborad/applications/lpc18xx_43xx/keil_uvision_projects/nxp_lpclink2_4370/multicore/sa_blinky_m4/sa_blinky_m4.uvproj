# Keil uVision project sa_blinky_m4.uvproj, settings and files
target spifi_nxp_lpclink2_4370 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: sa_blinky_m4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M4 USED_SSD1322_BX
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpclink2_4370;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\multicore\common;..\..\..\..\examples\multicore\sa_blinky_m4
  memory RVCT4: ROM 0x14000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../examples/multicore/common/: ipc_example.c ipc_msg.c m0_img_ldr.c readme.txt
    ../../../../examples/multicore/sa_blinky_m4/: blinky_m4.c
    ../../../../startup_code/: keil_startup_lpc18xx43xx.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpclink2_4370/keil_output/core_m4/: lib_lpc_board_4370.lib
