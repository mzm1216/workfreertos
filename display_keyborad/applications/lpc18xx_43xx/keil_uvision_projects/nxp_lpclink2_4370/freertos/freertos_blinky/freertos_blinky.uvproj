# Keil uVision project freertos_blinky.uvproj, settings and files
target spifi_nxp_lpclink2_4370 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4330 NXP
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: freertos_blinky
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: CORE_M4 USED_SSD2119
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpclink2_4370;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\examples\freertos\freertos_blinky;..\..\..\..\..\..\emwin\emWin_header;..\..\..\..\..\..\emwin\emWin_Config;..\..\..\..\..\..\emwin\emWin_X;..\..\..\..\..\..\emwin\emWin_header;..\..\..\..\examples\freertos\driver
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/freertos/startup_code/: keil_freertos_startup_lpc18xx43xx.s
    ../../../../examples/freertos/freertos_blinky/: main.c apptask.c trccom.c display.c kb_dev.c
  group freertos
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../examples/freertos/freertos_blinky/: readme.txt
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_4.c
  group emwinConfig
    ../../../../../../emwin/emWin_X/: GUI_X_FreeRTOS.c GUIConf.c LCDConf.c Oled_driver.c
  group emwinHead
    ../../../../../../emwin/emWin_header/: BUTTON.h CALENDAR.h CHECKBOX.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h EDIT.h FRAMEWIN.h Global.h GRAPH.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_IST3088.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D15G00.h GUIDRV_S1D13748.h GUIDRV_S1D13781.h GUIDRV_SLin.h GUIDRV_SPage.h GUIDRV_SSD1926.h GUIDRV_Template.h GUIDRV_TemplateI.h GUITDRV_ADS7846.h HEADER.h ICONVIEW.h IMAGE.h IMAGE_Private.h KNOB.h LCD.h LCD_ConfDefaults.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTVIEW.h LISTWHEEL.h MENU.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h PROGBAR.h RADIO.h SCROLLBAR.h SLIDER.h SPINBOX.h TEXT.h TREEVIEW.h WIDGET.h WM.h WM_GUI.h WM_Intern.h
  group emwinBitmap
    ../../../../../../emwin/emWin_bitmap/: HT24.c bjs.c cz2.c cz4.c HT29.c ST12.c mcx.c mcx1.c bmp1.c bmp3e.c bmp5.c colortest.c
    F:/works/同事/蒋蕾/新建文件夹111/新建文件夹/heart单色最终版/: heartstep1.c heartstep2.c heartstep3.c heartstep4.c heartstep5.c heartstep6.c heartstep7.c heartstep8.c
    F:/works/同事/蒋蕾/新建文件夹111/新建文件夹/msc最终版/: msc_black.c msc_white.c
    F:/works/同事/蒋蕾/新建文件夹111/新建文件夹/数据库bmp最终版/: db_black.c db_white.c
    F:/works/同事/蒋蕾/新建文件夹111/新建文件夹/网络连接bmp最终版/: net_black.c net_white.c
    F:/works/同事/蒋蕾/新建文件夹111/新建文件夹/背景最终版/: back_pic.c
    F:/works/同事/蒋蕾/新建文件夹111/新建文件夹/新建文件夹/CC/: up2.c down2.c
    F:/works/同事/王伟/OLED/演示版/: bmp11.c bmp12.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpclink2_4370/keil_output/core_m4/: lib_lpc_board_4370.lib
    ../../../../../../emwin/emWin_library/Keil/: emWin_M4F.lib
  group driver
    ../../../../examples/freertos/driver/: pinint.c uart.c dma.c driver_sct.c
